options:
  parameters:
    author: Miguel Anderson Buitrago Barbosa 2170488
    copyright: UIS
    description: multiplexacion de 6 segnales PAM
    generate_options: qt_gui
    id: ultima
    output_language: python
    title: '6 segnales '
  states: {}

blocks:
- name: d1
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '16'
  states: {}
- name: d2
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '32'
  states: {}
- name: d3
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '48'
  states: {}
- name: d4
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '64'
  states: {}
- name: d5
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: d6
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '80'
  states: {}
- name: fs
  id: variable
  parameters:
    value: 10e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: w
  id: variable_qtgui_range
  parameters:
    label: Ancho de pulso
    rangeType: int
    start: '0'
    step: '1'
    stop: '100'
    value: '16'
  states: {}
- name: PAM_0
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_0
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_1
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_2
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_3
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_4
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: PAM_0_5
  id: PAM
  parameters:
    d: w
    fs: fs
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: analog_sig_source_x_0_0_3
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_TRI_WAVE
  states: {}
- name: analog_sig_source_x_0_0_4
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SAW_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '6'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: d2
    type: float
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: d1
    type: float
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: d6
    type: float
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    delay: d3
    type: float
  states: {}
- name: blocks_delay_0_2
  id: blocks_delay
  parameters:
    delay: d4
    type: float
  states: {}
- name: blocks_delay_0_3
  id: blocks_delay
  parameters:
    delay: d5
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '7'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: 1024*3
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: '0'
    gain0: '0'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [PAM_0, '0', blocks_add_xx_0, '0']
- [PAM_0, '0', qtgui_time_sink_x_0, '0']
- [PAM_0_0, '0', blocks_delay_0_0, '0']
- [PAM_0_1, '0', blocks_delay_0, '0']
- [PAM_0_2, '0', blocks_delay_0_1, '0']
- [PAM_0_3, '0', blocks_delay_0_2, '0']
- [PAM_0_4, '0', blocks_delay_0_3, '0']
- [PAM_0_5, '0', blocks_float_to_complex_0, '0']
- [PAM_0_5, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0_0, '0', PAM_0, '0']
- [analog_sig_source_x_0_0_0, '0', PAM_0_0, '0']
- [analog_sig_source_x_0_0_1, '0', PAM_0_1, '0']
- [analog_sig_source_x_0_0_2, '0', PAM_0_2, '0']
- [analog_sig_source_x_0_0_3, '0', PAM_0_3, '0']
- [analog_sig_source_x_0_0_4, '0', PAM_0_4, '0']
- [blocks_add_xx_0, '0', blocks_delay_0_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_delay_0, '0', blocks_add_xx_0, '2']
- [blocks_delay_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_delay_0_0, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_delay_0_0_0, '0', PAM_0_5, '0']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '3']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0, '3']
- [blocks_delay_0_2, '0', blocks_add_xx_0, '4']
- [blocks_delay_0_2, '0', qtgui_time_sink_x_0, '4']
- [blocks_delay_0_3, '0', blocks_add_xx_0, '5']
- [blocks_delay_0_3, '0', qtgui_time_sink_x_0, '5']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
